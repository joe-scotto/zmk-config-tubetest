## config/boards/shields/tubetest/Kconfig.defconfig
```kconfig
if SHIELD_TUBETEST
            
config ZMK_KEYBOARD_NAME
    default "TubeTest"

endif
```
